## config/boards/shields/19RotaryPad/Kconfig.defconfig
```kconfig
if SHIELD_19ROTARYPAD

config ZMK_KEYBOARD_NAME
    default "19RotaryPad"

endif
```
